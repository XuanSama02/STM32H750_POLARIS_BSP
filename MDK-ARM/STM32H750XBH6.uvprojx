# Keil uVision project STM32H750XBH6.uvprojx, settings and files
target YMX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750XBH6 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\App;..\Core;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\STM32H7xx\Include;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\SYSTEM\DELAY;..\Drivers\SYSTEM\SYS;..\Drivers\SYSTEM\USART;..\Drivers\BSP\H750XBH6;..\Drivers\BSP\24CXX;..\Drivers\BSP\AP3216C;..\Drivers\BSP\DCMI;..\Drivers\BSP\DHT11;..\Drivers\BSP\DS18B20;..\Drivers\BSP\ES8388;..\Drivers\BSP\IIC;..\Drivers\BSP\JPEGCODEC;..\Drivers\BSP\KEY;..\Drivers\BSP\LED;..\Drivers\BSP\LCD;..\Drivers\BSP\MPU;..\Drivers\BSP\NAND;..\Drivers\BSP\NRF24L01;..\Drivers\BSP\OV5640;..\Drivers\BSP\PCF8574;..\Drivers\BSP\RTC;..\Drivers\BSP\SAI;..\Drivers\BSP\SDMMC;..\Drivers\BSP\SDRAM;..\Drivers\BSP\SPI;..\Drivers\BSP\TIMER;..\Drivers\BSP\USART2;..\Drivers\BSP\W25QXX;..\Middlewares\AUDIOCODEC\wav;..\Middlewares\FATFS\exfuns;..\Middlewares\FATFS\source;..\Middlewares\MALLOC;..\Middlewares\MJPEG;..\Middlewares\PICTURE;..\Middlewares\TEXT;..\Middlewares\USMART
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\SCRIPT\qspi_code_scf.scf
  group User
    ../Core/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Drivers/CMSIS/STM32H7xx/Source/: system_stm32h7xx.c
  group User/APP
    ../App/: audioplay.c videoplayer.c
  group Drivers/BSP
    ../Drivers/BSP/H750XBH6/: h750xbh6.c
    ../Drivers/BSP/24CXX/: 24cxx.c
    ../Drivers/BSP/ES8388/: es8388.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/JPEGCODEC/: jpegcodec.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/MPU/: mpu.c
    ../Drivers/BSP/PCF8574/: pcf8574.c
    ../Drivers/BSP/SAI/: sai.c
    ../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
    ../Drivers/BSP/SDRAM/: sdram.c
    ../Drivers/BSP/SPI/: spi.c
    ../Drivers/BSP/TIMER/: timer.c
    ../Drivers/BSP/W25QXX/: w25qxx.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/DELAY/: delay.c
    ../Drivers/SYSTEM/SYS/: sys.c
    ../Drivers/SYSTEM/USART/: usart.c
  group Drivers/Startup
    ../Drivers/CMSIS/STM32H7xx/Startup/: startup_stm32h750xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_nand.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c
  group Middlewares/AUDIOCODEC
    ../Middlewares/AUDIOCODEC/wav/: wavplay.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/MALLOC
    ../Middlewares/MALLOC/: malloc.c
  group Middlewares/MJPEG
    ../Middlewares/MJPEG/: avi.c mjpeg.c
  group Middlewares/TEXT
    ../Middlewares/TEXT/: fontupd.c text.c
  group Middlewares/USMART
    ../Middlewares/USMART/: usmart.c usmart_config.c usmart_str.c
